# Keil uVision project Cabinet.uvprojx, settings and files
target Cabinet (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CabinetDevice
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Source/: Retarget.c stm32f10x_it.c Main.c
  group W5500
    ../Source/W5500/Ethernet/: socket.c wizchip_conf.c
    ../Source/W5500/Ethernet/W5500/: w5500.c
    ../Source/W5500/Platform/: gpio_w5500.c
    ../Source/W5500/Application/: loopback_server.c loopback_client.c Application.c
    ../Source/W5500/Application/Buffer/PfmBuffer/: pfmBuffer.c
  group System
    ../Source/System/Usart/: usart1.c
    ../Source/System/: DMA.c NVIC.c RCC.c SID.c
    ../Source/System/Malloc/: malloc.c
    ../Source/System/Delay/: SysTick.c
    ../Source/System/SPI/: spi2.c spi3.c spi1.c
    ../Source/System/Timer/: timer1.c timer2.c timer3.c timer4.c
    ../Source/System/CRC/: crc.c
    ../Source/System/CAN/: can1.c
  group LCD12864
    ../Source/LCD12864/LCD12864P/: LCD12864P.C LCD12864P_main.C
    ../Source/LCD12864/: LCD12864_gpio.c
  group LED
    ../Source/GPIO/: led.c in.c out.c
  group ::Device
    D:/Program Files/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_crc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c
    RTE/Device/STM32F103VE/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
