# Keil uVision project CabinetDevice.uvprojx, settings and files
target CabinetDevice (ARM-ADS)
  device: STM32F401VE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CabinetDevice
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Ethernet
    ../Source/W5500/: Ethernet.c Retarget.c Serial.c
    ../Source/W5500/Application/: loopback.c
    ../Source/W5500/Ethernet/: socket.c wizchip_conf.c
    ../Source/W5500/Ethernet/W5500/: w5500.c
    ../Source/W5500/PlatformHandler/: dma_handler.c gpio_handler.c rcc_handler.c spi_handler.c timer_handler.c uart_handler.c
  group ::Device
    D:/Program Files/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_tim.c
    RTE/Device/STM32F401VE/: RTE_Device.h startup_stm32f401xx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
